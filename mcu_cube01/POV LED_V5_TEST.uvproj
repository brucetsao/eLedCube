# Keil uVision project POV LED_V5_TEST.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC11F16XE STC-STC11
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x3FFF) CLOCK(45000000) MODP2
  output: POV LED_V5_1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 74hc595.c Time.c display.c povdat.c IR.C Exti.c display_hand.c main.c IR_KEY.C EEPROM.C display_figure.c ds1302.c
